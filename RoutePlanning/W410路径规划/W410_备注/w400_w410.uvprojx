# Keil uVision project w400_w410.uvprojx, settings and files
target w400_w410_AliCloud (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401VCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: w400_w410 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ALICLOUD
  c include: .\core;.\std;.\components\StdPeriph_Driver\INC;.\components\StdPeriph_Driver\SRC;.\SRC;.\INC;.\components\StartUp;.\FreeRTOS;.\FreeRTOS\Source;.\FreeRTOS\Source\CMSIS_RTOS;.\FreeRTOS\Source\include;.\FreeRTOS\Source\portable\RVDS\ARM_CM4F;.\INC\Mode;.\INC\Wifi_Ali;.\INC\Wifi_Tuya;.\SRC\Mode;.\SRC\Wifi_Ali;.\SRC\Wifi_Tuya;.\SRC\Common;.\SRC\HAL;.\SRC\Moving;.\SRC\Thinking;.\SRC\W400_W410;.\INC\Moving;.\INC\Common;.\INC\Thinking;.\INC\W400_W410;.\INC\HAL;.\INC\Main;.\SRC\Main;.\INC\Touring;.\SRC\Touring
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT5: ROM 0x8008000 size 0x34000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group INC
    ./INC/: stm32f0xx_conf.h
  group Std
    ./components/StdPeriph_Driver/SRC/: misc.c
    ./components/StartUp/: startup_stm32f401xc.s system_stm32f4xx.c
  group Document
    ./Document/: history.txt
  group FreeRtos
    ./FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/Source/portable/MemMang/: heap_2.c
    ./FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ./FreeRTOS/: freertos.c
  group Mode
    ./SRC/Mode/: Mode_Charge.c Mode_Navigation.c Mode_Remote.c Mode_Sleep.c Mode_Spot.c Mode_Test.c Mode_Userinterface.c Mode_Wall.c Mode_None.c
  group Wifi_Tuya
    ./SRC/Wifi_Tuya/: Tuya.c Tuya_Math.c Tuya_Rx.c Tuya_Tx.c
  group Wifi_Ali
    ./SRC/Wifi_Ali/: AliCloud.c AliCloudRx.c AliCloudTx.c
  group Common
    ./SRC/Common/: Action.c Align.c CleanCycleCount.c Delay.c ErrorCode.c Heading.c Map.c Mode.c Movement.c MyMath.c ProjectTask.c Robot.c Station.c Timer.c Wifi.c Moving.c printf-stdarg.c Debug.c stm32f4xx_it.c Event.c Spot.c Detection.c RTC.c
  group HAL
    ./SRC/HAL/: Battery.c Bumper.c Button.c Charge.c Cliff.c CodeShow.c Display.c Gyro.c MainBrush.c Mobility.c Obs.c ObsMsg.c Power.c Pump.c Rcon.c RealTimeMonitor.c Remote.c SensorDriver.c Sleep.c Speaker.c System.c Test.c Vacuum.c Wall.c WaterTank.c Wheel.c Flash.c Hc4051.c
  group Moving
    ./SRC/Moving/: Docking.c Exception.c Movetopoint.c WallFollow.c BackStation.c
  group Thinking
    ./SRC/Thinking/: PathList.c PathPlanning.c PathPoint.c TargetList.c Line.c
  group W400_W410
    ./SRC/W400_W410/: Hw_Battery.c Hw_Bumper.c Hw_Button.c Hw_Adc.c Hw_Charge.c Hw_Cliff.c Hw_CodeShow.c Hw_Display.c Hw_SysInitialize.c Hw_Usart.c Hw_Hc4051.c Hw_MainBrush.c Hw_Power.c Hw_Pump.c Hw_Rcon.c Hw_Speaker.c Hw_System.c Hw_Vacuum.c Hw_WaterTank.c Hw_Obs.c Hw_Wheel.c Hw_Sleep.c Hw_RTC.c
  group Main
    ./SRC/Main/: main.c
  group Touring
    ./SRC/Touring/: Touring.c
target w400_w410_Tuya (ARM-ADS)
  device: STM32F401VCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: w400_w410 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TUYA
  c include: .\core;.\std;.\components\StdPeriph_Driver\INC;.\components\StdPeriph_Driver\SRC;.\SRC;.\INC;.\components\StartUp;.\FreeRTOS;.\FreeRTOS\Source;.\FreeRTOS\Source\CMSIS_RTOS;.\FreeRTOS\Source\include;.\FreeRTOS\Source\portable\RVDS\ARM_CM4F;.\INC\Common;.\INC\HAL;.\INC\Main;.\INC\Mode;.\INC\Moving;.\INC\Thinking;.\INC\W400_W410;.\INC\Wifi_Ali;.\INC\Wifi_Tuya;.\SRC\Common;.\SRC\HAL;.\SRC\Main;.\SRC\Mode;.\SRC\Moving;.\SRC\Thinking;.\SRC\W400_W410;.\SRC\Wifi_Ali;.\SRC\Wifi_Tuya;.\SRC\Touring;.\INC\Touring
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT5: ROM 0x8008000 size 0x34000
  memory RVCT9: RAM 0x20000000 size 0x10000
